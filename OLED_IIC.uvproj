# Keil uVision project OLED_IIC.uvproj, settings and files
target Target 1 (MCS-51)
  device: ML51DB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: OLED_IIC
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc;Core\BSP\OLED;Libs\Font
  group StartUP
    ./: ML51_STARTUP.A51
  group Core
    ./Core/: main.c
  group OLED
    Core/BSP/OLED/: oled_disp.c oled_i2c.c
  group Font
    Libs/Font/: font.c font_data.c
